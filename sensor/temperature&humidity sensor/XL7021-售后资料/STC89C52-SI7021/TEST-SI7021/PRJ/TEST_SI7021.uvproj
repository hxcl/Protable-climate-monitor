# Keil uVision project TEST_SI7021.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TEST_SI7021 +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER-MAIN
    ../USER-MAIN/: USER-MAIN.c
  group MCU/MCU_STC11L04
    ../MCU/: MCU-STC11L04.c
  group HARDWARE/SI7021
    ../HARDWARE/SI7021/: SI7021.c
  group LCD
    ../LCD/: lcd.c
